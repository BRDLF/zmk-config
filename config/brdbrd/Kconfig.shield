## config/brdbrd/Kconfig.shield
```kconfig
# Copyright (c) 2022 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_BRDBRD
	def_bool $(shields_list_contains,brdbrd)
```
